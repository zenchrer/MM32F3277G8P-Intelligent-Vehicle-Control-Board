# Repository zenchrer/MM32F3277G8P-Intelligent-Vehicle-Control-Board

File README.md:

# MM32F3277G8P-Intelligent-Vehicle-Control-Board

## 已添加[Sbus解析例程](https://github.com/zenchrer/MM32-Sbus-Demo.git)<br>
8/31/2022 9:24:01 PM <br>
&nbsp;&nbsp;&nbsp;&nbsp;本项目是2022年全国大学生智能车竞赛平衡信标组桂林信息科技学院Tornado(队)的硬件开源;
在一块PCB上集成了电机驱动以及其它外设接口,基本满足平衡信标组的功能需求,引脚大部分兼容某飞科技的开源程序,某飞的代码虽然有些BUG,但是大体方便可靠(个人认为比隔壁lq的好);电源部分设计参考了2021年立创开源广场moximoxi大佬的开源硬件:[传送门](https://oshwhub.com/moximoxi/shuang-jum3_mini)<br>

***
### 主要特点
+ 主控采用了灵动微电子MM32F3277G8P作为MCU;<br>
+ 电机驱动使用之前开源的EG3013栅极驱动以及N-Channel Mosfet;<br>
+ 预留S-bus接口,方便老车退役改成遥控车;(bushi)<br>
+ 预留并口屏,理论上相比SPI屏幕刷新更快,节约CPU时间;
+ 使用开源EDA软件Kicad6.0.2绘制;
***
### 开发者
组织：桂林信息科技学院 通信创新实践基地<br>
作者：zenchrer [邮箱](zenchrer@qq.com)
***

### 外观

***

## KiCad design MM32F3277G8P_Board_Vesuvio.kicad_pcb

Parts:
BZ1: Buzzer; MagneticBuzzer_PUI_AT-0927-TT-6-R
C1, C2, C3, C4, C5, C6, C7, C18, C19, C28, C29, C30, C37: 100nF; C_0603_1608Metric
C8, C9: 10uF; C_0805_2012Metric
C10, C11, C12, C13, C14, C15, C16, C17, C31, C32, C40, C43, C44: 100uF; C_1210_3225Metric
C20, C21, C22, C23, C33, C34, C35, C36: 10nF; C_0402_1005Metric
C24, C25, C26, C27, C38, C39, C41, C42: 22uF; C_0805_2012Metric
D1, D2, D3: LED_Small; LED_0603_1608Metric
D4, D5, D6, D7, D9, D10, D11, D12: 1N4148; D_SOD-123
D8: SS54; D_SMA
D13: 1N4007; D_SMA
H1, H2, H4, H5: Pad; MountingHole_2.2mm_M2_Pad_Via
H3, H6: Pad; MountingHole_2.5mm_Pad_Via
IC1: XL1509-5.0E1; SOIC-8_3.9x4.9mm_P1.27mm; Manufacturer_Part_Number XL1509-5.0E1
J1, J2: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J4: Conn_01x08_Female; PinHeader_1x08_P2.54mm_Vertical
J5, J8: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
J6: Conn_01x18_MountingPin; TE_1-1734839-8_1x18-1MP_P0.5mm_Horizontal
J7: Conn_01x03_MountingPin; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal
L1: 68uH; L_7.3x7.3_H3.5
L2: 磁珠; Fuse_0805_2012Metric
Q1, Q10: MMSS8050; SOT-23
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9: QM6006D; TO-252-2
R1: 510R; R_0603_1608Metric
R2: 510K; R_0603_1608Metric
R3, R4, R5, R6, R7, R8, R9, R10, R20, R25, R27, R29: 10K; R_0603_1608Metric
R11: 10k; R_0603_1608Metric
R12, R13, R14, R15: 1k; R_0603_1608Metric
R16, R17, R18, R19, R21, R22, R23, R24: 22R; R_0402_1005Metric
R26: 50K; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; SW_SPST_PTS810
SW7: SW_SPDT; MTS102
U1: MM32F3277G8P; LQFP-100_14x14mm_P0.5mm
U2: RT9013-33GB; SOT-23-5; PARTREV Aprill 2011
U3, U4, U5, U6: EG3013; SOIC-8_3.9x4.9mm_P1.27mm
U7: LR1801G-33-SH2-R; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm_ThermalVias
Y1: 8Mhz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+3.3VP: BZ1.1 (-), C37.1, C40.1, C43.1, D13.2 (A), J3.4, J4.1, J5.2, J6.17, J6.18, J8.2, R4.1, R7.1, R8.1, R9.1, R10.1, R29.1, SW1.2, U7.1 (VOUT)
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, R5.1, R6.1, U1.6 (VBAT), U1.11 (VDD), U1.21 (VREF+), U1.22 (VDDA), U1.28 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U2.5 (VOUT)
+5V: C9.1, C30.1, C31.1, C32.1, IC1.3 (FEEDBACK), J7.2, L1.1, R20.2, U2.1 (VIN), U2.3 (EN), U7.8 (VIN)
+12V: C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C28.1, C29.1, C44.1, IC1.1 (VIN), Q2.2 (D), Q4.2 (D), Q6.2 (D), Q8.2 (D), R11.1, R26.1, SW7.1 (A), U3.1 (VCC), U4.1 (VCC), U5.1 (VCC), U6.1 (VCC)
+BATT: H3.1, SW7.2 (B)
BATT_VOTAGE: R26.2, R27.1, U1.33 (PC4)
BOOT0: R3.2, SW1.1, U1.94 (BOOT0)
BUZZER: Q1.1 (B), R25.2, U1.96 (PB9)
CAM_D0: J6.8, U1.39 (PE8)
CAM_D1: J6.9, U1.40 (PE9)
CAM_D2: J6.10, U1.41 (PE10)
CAM_D3: J6.11, U1.42 (PE11)
CAM_D4: J6.12, U1.43 (PE12)
CAM_D5: J6.13, U1.44 (PE13)
CAM_D6: J6.14, U1.45 (PE14)
CAM_D7: J6.15, U1.46 (PE15)
CAM_PCLK: J6.1, U1.38 (PE7)
CAM_RX: J6.4, U1.98 (PE1)
CAM_TX: J6.3, U1.97 (PE0)
CAM_VSYNC: J6.6, U1.5 (PE6)
CCD_AO: U1.36 (PB1)
CCD_CLK: U1.37 (PB2)
CCD_SI: U1.89 (PB3)
ENC_A1: J8.3, U1.90 (PB4)
ENC_A2: J5.3, U1.92 (PB6)
ENC_B1: J8.4, U1.91 (PB5)
ENC_B2: J5.4, U1.93 (PB7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.1, C23.1, C28.2, C29.2, C30.2, C31.2, C32.2, C34.1, C36.1, C37.2, C40.2, C43.2, C44.2, D2.1 (K), D3.1 (K), D8.2 (A), H6.1, IC1.4 (ON/OFF), IC1.5 (GND_1), IC1.6 (GND_2), IC1.7 (GND_3), IC1.8 (GND_4), J3.2, J4.2, J5.1, J6.2, J6.7, J6.16, J6.MP (MountPin), J7.1, J7.MP (MountPin), J8.1, L2.1, Q1.2 (E), Q3.3 (S), Q5.3 (S), Q7.3 (S), Q9.3 (S), Q10.2 (E), R3.1, R12.2, R13.2, R14.2, R15.2, R25.1, R27.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, U1.10 (VSS), U1.19 (VSSA), U1.20 (VREF-), U1.27 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U2.2 (GND), U3.4 (COM), U4.4 (COM)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
ICM_CS: J4.6, U1.51 (PB12)
ICM_SAO/SDO: J4.5, U1.53 (PB14)
ICM_SCL/SPC: J4.3, U1.52 (PB13)
ICM_SDA/SDI: J4.4, U1.54 (PB15)
IN1: R13.1, U1.23 (PA0), U3.2 (HIN), U3.3 (~LIN)
IN2: R12.1, U1.24 (PA1), U5.2 (HIN), U5.3 (~LIN)
IN3: R14.1, U1.25 (PA2), U4.2 (HIN), U4.3 (~LIN)
IN4: R15.1, U1.26 (PA3), U6.2 (HIN), U6.3 (~LIN)
IPS_D0: J3.1, U1.55 (PD8)
IPS_D1: J3.3, U1.56 (PD9)
IPS_D2: J3.5, U1.57 (PD10)
IPS_D3: J3.7, U1.58 (PD11)
IPS_D4: J3.9, U1.59 (PD12)
IPS_D5: J3.11, U1.60 (PD13)
IPS_D6: J3.13, U1.61 (PD14)
IPS_D7: J3.15, U1.62 (PD15)
KEY_1: R9.2, SW3.1, U1.1 (PE2)
KEY_2: R10.2, SW5.1, U1.2 (PE3)
KEY_3: R7.2, SW4.1, U1.3 (PE4)
KEY_4: R8.2, SW6.1, U1.4 (PE5)
L0: U1.15 (PC0)
L1: U1.16 (PC1)
L2: U1.17 (PC2)
L3: U1.18 (PC3)
LED: D1.1 (K), U1.7 (PC13)
NRST: C7.2, J2.2, R4.2, SW2.1, U1.14 (NRST)
unnamed: BZ1.2 (+), Q1.3 (C)
unnamed: C20.2, D4.2 (A), Q2.1 (G), R16.1
unnamed: C21.2, D5.2 (A), Q3.1 (G), R17.1
unnamed: C22.2, D6.2 (A), Q4.1 (G), R18.1
unnamed: C23.2, D7.2 (A), Q5.1 (G), R19.1
unnamed: C24.1, C26.1, U3.8 (VB)
unnamed: C25.1, C27.1, U4.8 (VB)
unnamed: C33.2, D9.2 (A), Q6.1 (G), R21.1
unnamed: C34.2, D10.2 (A), Q7.1 (G), R22.1
unnamed: C35.2, D11.2 (A), Q8.1 (G), R23.1
unnamed: C36.2, D12.2 (A), Q9.1 (G), R24.1
unnamed: C38.1, C41.1, U5.8 (VB)
unnamed: C39.1, C42.1, U6.8 (VB)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), R6.2
unnamed: D3.2 (A), R11.2
unnamed: D4.1 (K), R16.2, U3.7 (HO)
unnamed: D5.1 (K), R17.2, U3.5 (LO)
unnamed: D6.1 (K), R18.2, U4.7 (HO)
unnamed: D7.1 (K), R19.2, U4.5 (LO)
unnamed: D8.1 (K), IC1.2 (OUTPUT), L1.2
unnamed: D9.1 (K), R21.2, U5.7 (HO)
unnamed: D10.1 (K), R22.2, U5.5 (LO)
unnamed: D11.1 (K), R23.2, U6.7 (HO)
unnamed: D12.1 (K), R24.2, U6.5 (LO)
unnamed: D13.1 (K), J1.1
unnamed: J1.4, L2.2
unnamed: J7.3, Q10.1 (B)
unnamed: R1.1, Y1.3
unnamed: R1.2, R2.2, U1.13 (RCC_OSC_OUT)
unnamed: R2.1, U1.12 (RCC_OSC_IN), Y1.1
unnamed: R20.1, U7.2 (ON/OFF#)
OUT1: C20.1, C24.2, C26.2, H1.1, Q2.3 (S), Q3.2 (D), U3.6 (VS)
OUT2: C33.1, C38.2, C41.2, H4.1, Q6.3 (S), Q7.2 (D), U5.6 (VS)
OUT3: C22.1, C25.2, C27.2, H2.1, Q4.3 (S), Q5.2 (D), U4.6 (VS)
OUT4: C35.1, C39.2, C42.2, H5.1, Q8.3 (S), Q9.2 (D), U6.6 (VS)
SDIOCLK: U1.80 (PC12)
SDIO_CMD: U1.83 (PD2)
SDIO_D0: U1.65 (PC8)
SDIO_D1: U1.66 (PC9)
SDIO_D2: U1.78 (PC10)
SDIO_D3: U1.79 (PC11)
SERVO_PWM: U1.77 (PA15)
SWCLK: J1.3, U1.76 (PA14)
SWDIO: J1.2, U1.72 (PA13)
TFT_BL: J3.16, U1.82 (PD1)
TFT_CS: J3.14, U1.29 (PA4)
TFT_DC: J3.12, U1.81 (PD0)
TFT_RST: J3.10, U1.31 (PA6)
TFT_SCL/D0: J3.6, U1.30 (PA5)
TFT_SDA/D1: J3.8, U1.32 (PA7)
UART1_RX: J2.4, U1.69 (PA10)
UART1_TX: J2.3, U1.68 (PA9)
UART2_RX: U1.86 (PD5)
UART2_TX: U1.87 (PD6)
UART3_RX: Q10.3 (C), R29.2, U1.48 (PB11)
UART3_TX: U1.47 (PB10)
UART6_RX: U1.63 (PC6)
UART6_TX: U1.64 (PC7)

Notes on the sheet:
SENSOR_3V3
MCU_3V3
IMU
PWR_FLAG
DC_IN
SWD
ENC1
MOTOR_H-BRIDGE_DRIVE
MCU_NRST
单片机的UART8 TX
SBUS
BUTTONS
ENC2
此处实际没找到22uF的电容， 板子上装的是10uF的，芯片手 册上是这个位置47uF电容
单片机的UART8 RX
MCU_BOOT
INTERFACE
BUZZER
DCDC_5V
CAM
TFT

Board: 4 copper layers, 88.0 x 58.0 mm, 128 parts (8 on the bottom side), 94 nets.

## Commit log

2022-08-24 add pcb and sch
2022-08-24 add images
2022-08-27 添加Sbus 解析例程
2022-08-27 fix some bugs
2022-08-29 添加部分注释
2022-08-29 Sbus例程移除
2022-08-29 更细子仓库到主仓库代码库中
2022-08-29 Update MM32-Sbus-Demo
2022-08-29 rm modeles
